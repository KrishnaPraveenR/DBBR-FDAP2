# IAR project BBR Honeywell.ewp, settings and files
configuration DBBR_ResetToFactory (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: AT91SAM7X512 Atmel AT91SAM7X512
  ICCARM.CCDefines: at91sam7x512; DEVICE_TYPE=4; BACKBONE_SUPPORT; __monitor=; _UAP_TYPE=0; _DEMOAPP_TYPE=0; WCI_SUPPORT; WCI_TEXT_SUPPORT; PLATFORM=PLATFORM_HN_BBR; DEBUG_MSG_DELAY; WCI_DLL_COMPLIANCE; RESET_TO_FACTORY; CC2420_AES_H; BBR2_HW
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.PreInclude: sources\logger\logger_ack.h
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: at91sam7x512; flash
  OBJCOPY.OOCOutputFile: DBBR2_Honeywell_factoryimage.bin
  postbuild: Build_DBBR_Factory.bat
  ILINK.IlinkOutputFile: DBBR Honeywell.out
  ILINK.IlinkIcfFile: board support\5_20_at91SAM7X512_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration DBBR_Platform (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: at91sam7x512; DEVICE_TYPE=4; BACKBONE_SUPPORT; __monitor=; _UAP_TYPE=0; _DEMOAPP_TYPE=0; WCI_SUPPORT; WCI_TEXT_SUPPORT; PLATFORM=PLATFORM_HN_BBR; DEBUG_MSG_DELAY; WCI_DLL_COMPLIANCE; BBR2_HW; CC2420_AES_H
  ICCARM.CCIncludePath2: CC2520; CommonAPI; Ethernet; Ipv4; Stack; 
  OBJCOPY.OOCOutputFile: DBBR_Honeywell.bin
  postbuild: C:\OneWireless\DBBR2_FINAL_MASTER.v1\Build_DBBR_Platform.bat
  group (top)
    sources/: at91sam7x512_map.h bootl.c digitals.c eth.c global.c i2c.c itc.c main.c packet_combine.c spi0.c spi1.c spi_eeprom.c spi_pa_dac.c system.h timers.c timers.h typedef.h usart.c UT_main.c wdt.h
  group board_support
    board support/: 5_20_Cstartup.s 5_20_Cstartup_SAM7.c AT91SAM7X512.h board.h
  group CC2520
    sources/CC2520/: CC2520.c CC2520.h CC2520_AES.c CC2520_AES.h CC2520_Macros.h
  group CommonAPI
    sources/CommonAPI/: Common_API.c Common_API.h DAQ_Comm.c DAQ_Comm.h RadioApi.h
  group ethernet
    sources/ethernet/: emac.c emac.h IPlookup.c IPlookup.h
  group ethernet/bcm5221
    sources/ethernet/bcm5221/: bcm5221.c bcm5221.h bcm5221_define.h
  group ipv4
    sources/ipv4/: udp.c udp.h udpqueue.c udpqueue.h
  group isa100
    sources/Isa100/: aslde.c aslsrvc.c dlde.c dlme.c dlmo_utils.c dmap.c dmap_armo.c dmap_co.c dmap_dlmo.c dmap_dmo.c dmap_dpo.c dmap_udo.c dmap_utils.c mlde.c mlsm.c nlde.c nlme.c phy.c provision.c slme.c tlde.c tlme.c uap.c uap_data.c uap_mo.c
  group logger
    sources/logger/: err.h logger.c logger.h logger_ack.c logger_ack.h
  group text
    sources/text/: text_convertor.c text_convertor.h
